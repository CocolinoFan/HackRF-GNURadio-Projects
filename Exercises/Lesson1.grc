options:
  parameters:
    author: cocolino
    copyright: GNU General Public License
    description: https://www.youtube.com/watch?v=ufxBX_uNCa0
    generate_options: qt_gui
    id: untitled
    output_language: python
    title: Wave, mic visualize
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    label: 'Frequency '
    start: '10'
    step: '10'
    stop: 100e3
    value: '1000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sig_trype
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0
    label: Signal Type
    label0: Sine
    label1: Square
    num_opts: '2'
    option0: '101'
    option1: '103'
    type: int
    value: '101'
    widget: radio_buttons
  states: {}
- name: uisellect
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,1
    label0: Mic
    label1: Signal source
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: sig_trype
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: uisellect
    num_inputs: '2'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle2_0, '0']
- [audio_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_float_to_complex_0, '0', blocks_selector_0, '0']
- [blocks_selector_0, '0', qtgui_sink_x_0, '0']
- [blocks_throttle2_0, '0', blocks_selector_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
