options:
  parameters:
    author: cocolino
    copyright: GNU General Public License
    description: https://youtu.be/m0GGBFBWFfU
    generate_options: qt_gui
    id: default
    output_language: python
    title: Simple AM RX
  states: {}

blocks:
- name: af_gain
  id: variable_qtgui_range
  parameters:
    label: Volume
    start: '0'
    step: '1'
    stop: '5'
    value: '1'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequnecy
    type: real
    value: offset_coarse+offset_fine
  states: {}
- name: offset_coarse
  id: variable_qtgui_range
  parameters:
    label: Coarse Tune
    start: 1e6
    step: '500'
    stop: 20e6
    value: 1e6
  states: {}
- name: offset_fine
  id: variable_qtgui_range
  parameters:
    label: Fine tune
    start: '-1e3'
    step: '1'
    stop: 1e3
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    start: '0'
    step: '1'
    stop: '100'
    value: '75'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.048e6
  states: {}
- name: width
  id: variable_qtgui_range
  parameters:
    label: Filter
    start: 2e3
    step: '1'
    stop: 40e3
    value: 10e3
  states: {}
- name: analog_agc3_xx_0
  id: analog_agc3_xx
  parameters:
    attack_rate: '0.1'
    decay_rate: '0.01'
    gain: '1.0'
    iir_update_decim: '1'
    max_gain: '65536'
    reference: '0.7'
    type: complex
  states: {}
- name: analog_am_demod_cf_0
  id: analog_am_demod_cf
  parameters:
    audio_decim: '1'
    audio_pass: '5000'
    audio_stop: '5500'
    chan_rate: 48e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: af_gain
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '32'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 1.5e3
    win: window.WIN_HAMMING
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '10'
    bw0: 20e6
    freq0: freq
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '10'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: '"Raw"'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate/32
    fc: '0'
    fftsize: '1024'
    name: '"Filtered"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '12'
    type: ccc
  states: {}

connections:
- [analog_agc3_xx_0, '0', analog_am_demod_cf_0, '0']
- [analog_am_demod_cf_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_sink_x_0_0, '0']
- [low_pass_filter_0, '0', rational_resampler_xxx_0, '0']
- [osmosdr_source_0, '0', low_pass_filter_0, '0']
- [osmosdr_source_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', analog_agc3_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
